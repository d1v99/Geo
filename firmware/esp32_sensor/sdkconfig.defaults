## firmware/esp32_sensor/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_CSI_ENABLED=y
CONFIG_ESP32_WIFI_CSI_ENABLED=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
